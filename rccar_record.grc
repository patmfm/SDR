options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '50019000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '10'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/patmfm/Desktop/RC_car/carup.raw
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '0'
    args: '"hackrf"'
    bb_gain0: '40'
    bw0: '2000000'
    freq0: freq
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
