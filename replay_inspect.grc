options:
  parameters:
    author: patmfm
    generate_options: qt_gui
    id: replay_inspect
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 48e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '500000'
    fc: samp_rate
    fftsize: '1024'
    type: complex
  states: {}
- name: sandia_utils_file_source_0_0
  id: sandia_utils_file_source
  parameters:
    begin_tag: pmt.PMT_NIL
    file: /home/patmfm/Desktop/RC_car/car
    file_tags: 'False'
    file_type: raw
    force_new: 'False'
    msg_period_ms: '1000'
    queue_depth: '100'
    rate: int(samp_rate)
    repeat: 'True'
    type: complex
    vlen: '1'
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0_0, '0']
- [sandia_utils_file_source_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
