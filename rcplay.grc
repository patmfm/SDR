options:
  parameters:
    author: patmfm
    generate_options: qt_gui
    id: rcplay
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '50019000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000.000000'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: '0'
    bb_gain0: '40'
    bw0: '16000000'
    corr0: '-5200'
    freq0: freq
    gain0: '30'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '500000'
    fc: samp_rate
    fftsize: '1024'
    type: complex
  states: {}
- name: sandia_utils_file_source_0
  id: sandia_utils_file_source
  parameters:
    begin_tag: pmt.PMT_NIL
    file: /home/patmfm/Desktop/RC_car/car_down_right.raw
    file_tags: 'False'
    file_type: raw_header
    force_new: 'False'
    msg_period_ms: '1000'
    queue_depth: '100'
    rate: int(samp_rate)
    repeat: 'True'
    type: complex
    vlen: '1'
  states: {}

connections:
- [sandia_utils_file_source_0, '0', osmosdr_sink_0, '0']
- [sandia_utils_file_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
